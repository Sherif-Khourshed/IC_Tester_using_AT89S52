# Keil uVision project lcd_interfacing.uvproj, settings and files
target LCD interfacing with 4 data lines (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 20x4 lcd_interfacing4bit +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Source Code
    ./: main.c lcd.c delay.c
  group Header files
    ./: lcd.h delay.h
